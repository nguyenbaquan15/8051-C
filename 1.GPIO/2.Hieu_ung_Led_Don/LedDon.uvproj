# Keil uVision project LedDon.uvproj, settings and files
target LedDon (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: OrBit +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Libraries\inc
  group main
    ./: main.c
  group lib
    ../../Libraries/inc/: delay.h led_don.h
    ../../Libraries/src/: delay.c led_don.c
